inherit image-sign
